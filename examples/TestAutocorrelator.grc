options:
  parameters:
    generate_options: qt_gui
    id: test_autocorrelator
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2441e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_AutoCorrelatorSink_0
  id: guiextra_AutoCorrelatorSink
  parameters:
    autoScale: 'False'
    fac_decimation: '10'
    fac_size: '512'
    grid: 'True'
    gui_hint: 2,0,1,3
    sampRate: samp_rate
    title: '"Fast Autocorrelation Sink"'
    useDB: 'False'
    yMax: '1'
    yMin: '0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 0,0,1,3
    plotconst: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', guiextra_AutoCorrelatorSink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
