options:
  parameters:
    generate_options: qt_gui
    id: test_led
    output_language: python
    title: Test LED Indicator
  states: {}

blocks:
- name: ledstate
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Variable-based LED State
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_toggle_button_msg_0
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0,1,1,1
    initPressed: 'True'
    label: Msg Based State
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'True'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_ledindicator_0
  id: guiextra_ledindicator
  parameters:
    gui_hint: 1,0,1,1
    label: '"State"'
    maxSize: '40'
    offColor: red
    onColor: green
    position: '1'
    state: ledstate
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [variable_qtgui_toggle_button_msg_0, state, guiextra_ledindicator_0, state]

metadata:
  file_format: 1
