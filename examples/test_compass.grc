options:
  parameters:
    generate_options: qt_gui
    id: test_compass
    output_language: python
    title: Test Compass
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_dial_control_0
  id: variable_qtgui_dial_control
  parameters:
    label: Angle
    maximum: '360'
    minimum: '0'
    showvalue: 'True'
    type: int
    value: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_compass_0
  id: guiextra_compass
  parameters:
    backgroundColor: white
    fullNeedle: '1'
    min_size: '250'
    name: Azimuth
    needleBodyColor: black
    needleTipColor: red
    position: '1'
    scaleColor: black
    setDebug: 'False'
    update_time: '0.10'
    usemsg: 'True'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [variable_qtgui_dial_control_0, value, guiextra_compass_0, angle]

metadata:
  file_format: 1
