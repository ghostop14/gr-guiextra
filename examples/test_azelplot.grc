options:
  parameters:
    generate_options: qt_gui
    id: test_azelplot
    output_language: python
    title: Test Az-El Plot
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gpredict_rotor_0
  id: gpredict_rotor
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '4533'
    minEl: '10.0'
    verbose: 'False'
  states: {}
- name: variable_qtgui_azelplot_0
  id: variable_qtgui_azelplot
  parameters:
    backgroundColor: '#efefef'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [gpredict_rotor_0, az_el, variable_qtgui_azelplot_0, azel]

metadata:
  file_format: 1
