options:
  parameters:
    generate_options: qt_gui
    id: test_graphic_overlay
    output_language: python
    title: Test Graphic Item Overlay
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_graphicitem_0
  id: guiextra_graphicitem
  parameters:
    file: /opt/sdr/gnuradio/gr-guiextra38/examples/gnuradio_logo.png
    fixedsize: 'False'
    height: '240'
    scaleImage: 'False'
    width: '320'
  states: {}
- name: guiextra_graphicoverlay_0
  id: guiextra_graphicoverlay
  parameters:
    listDelay: '1.0'
    overlayList: '[{''filename'':''/opt/sdr/gnuradio/gr-guiextra38/examples/exampleoverlay.png'',''x'':10,''y'':0,''scalefactor'':1},{''filename'':''/opt/sdr/gnuradio/gr-guiextra38/examples/exampleoverlay.png'',''x'':20,''y'':20,''scalefactor'':2},{''filename'':''/opt/sdr/gnuradio/gr-guiextra38/examples/exampleoverlay.png'',''x'':30,''y'':40,''scalefactor'':2},{''filename'':''/opt/sdr/gnuradio/gr-guiextra38/examples/exampleoverlay.png'',''x'':40,''y'':60,''scalefactor'':3},{''filename'':''/opt/sdr/gnuradio/gr-guiextra38/examples/exampleoverlay.png'',''x'':50,''y'':80,''scalefactor'':4}]'
    repeat: 'True'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [guiextra_graphicoverlay_0, overlay, blocks_message_debug_0, print]
- [guiextra_graphicoverlay_0, overlay, guiextra_graphicitem_0, overlay]

metadata:
  file_format: 1
