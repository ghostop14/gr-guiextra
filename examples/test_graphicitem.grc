options:
  parameters:
    generate_options: qt_gui
    id: test_graphicitem
    output_language: python
    title: Test Graphic Item
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_graphicitem_0
  id: guiextra_graphicitem
  parameters:
    file: /opt/sdr/gnuradio/gr-guiextra38/examples/gnuradio_logo.png
    fixedsize: 'False'
    height: '100'
    scaleImage: 'False'
    width: '200'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
