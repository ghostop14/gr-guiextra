options:
  parameters:
    generate_options: qt_gui
    id: test_msgchkstr
    output_language: python
    title: Test Msg Checkbox
  states: {}

blocks:
- name: filename
  id: variable_qtgui_msgcheckbox
  parameters:
    cellalignment: '2'
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: File
    outputmsgname: filename
    pressed: /opt/sdr/gnuradio/Flowgraphs/Production/gnuradio_logo.jpg
    released: /opt/sdr/gnuradio/Flowgraphs/Production/noaa19.jpeg
    type: string
    value: /opt/sdr/gnuradio/Flowgraphs/Production/noaa19.jpeg
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_graphicitem_0
  id: guiextra_graphicitem
  parameters:
    file: /opt/sdr/gnuradio/Flowgraphs/Production/noaa19.jpeg
    fixedsize: 'False'
    gui_hint: 1,0,1,1
    height: '0'
    scaleImage: 'False'
    width: '0'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [filename, state, blocks_message_debug_0, print]
- [filename, state, guiextra_graphicitem_0, filename]

metadata:
  file_format: 1
