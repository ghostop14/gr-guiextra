options:
  parameters:
    generate_options: qt_gui
    id: test_toggle
    output_language: python
    title: Test Toggle Button
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: state
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: State
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_ledindicator_0
  id: guiextra_ledindicator
  parameters:
    cellalignment: '1'
    gui_hint: 0,1,1,1
    label: '"State"'
    maxSize: '40'
    offColor: red
    onColor: green
    position: '1'
    state: state
    verticalalignment: '1'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [state, state, blocks_message_debug_0, print]

metadata:
  file_format: 1
