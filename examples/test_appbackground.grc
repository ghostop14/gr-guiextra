options:
  parameters:
    generate_options: qt_gui
    id: test_appbackground
    output_language: python
    title: Test App Background
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_grbackground_0
  id: guiextra_grbackground
  parameters:
    alignment: center
    file: /opt/sdr/gnuradio/gr-guiextra38/examples/gnuradio_logo.png
    relBackgroundColor: default
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
