options:
  parameters:
    generate_options: qt_gui
    id: test_levelgauge
    output_language: python
    title: Test Level Gauge
  states: {}

blocks:
- name: guiextra_levelgauge_0
  id: guiextra_levelgauge
  parameters:
    backgroundColor: default
    barColor: default
    fontColor: default
    gui_hint: 0,1,1,2
    isVertical: 'False'
    label: Value Test
    maximum: '100'
    minimum: '0'
    msize: '300'
    position: '1'
    scaleFactor: '1'
    showValue: 'True'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: val
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 0,0,1,1
    label: Value
    maximum: '100'
    minimum: '0'
    relBackgroundColor: green
    showvalue: 'True'
    type: int
    value: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [val, value, guiextra_levelgauge_0, value]

metadata:
  file_format: 1
