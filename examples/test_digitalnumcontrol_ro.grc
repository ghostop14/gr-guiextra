options:
  parameters:
    generate_options: qt_gui
    id: test_dignum_ro
    output_language: python
    title: Test Digital Number Control
  states: {}

blocks:
- name: freq
  id: guiextra_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: ','
    gui_hint: 0,1,1,1
    lbl: Frequency
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    readOnly: 'True'
    relBackgroundColor: black
    relFontColor: gray
    value: input_freq
  states: {}
- name: input_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: 90e6
    step: 1e3
    stop: 100e6
    value: 95.7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: Freq
    type: real
    value: freq
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [freq, valueout, blocks_message_debug_0, print]

metadata:
  file_format: 1
