options:
  parameters:
    generate_options: qt_gui
    id: show_controls
    output_language: python
    title: gr-guiextra
  states: {}

blocks:
- name: angle
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,0,1,1
    label: Angle
    maximum: '360'
    minimum: '0'
    showvalue: 'True'
    type: int
    value: '25'
  states: {}
- name: freq
  id: guiextra_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: ','
    gui_hint: 0,0,1,2
    lbl: Frequency
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    readOnly: 'False'
    relBackgroundColor: black
    relFontColor: white
    value: 139.712e6
  states: {}
- name: gain
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,3,1,1
    label: Gain
    maximum: '100'
    minimum: '0'
    relBackgroundColor: aqua
    showvalue: 'False'
    type: int
    value: '6'
  states: {}
- name: guiextra_levelgauge_0
  id: guiextra_levelgauge
  parameters:
    backgroundColor: default
    barColor: default
    fontColor: default
    gui_hint: 1,4,1,1
    isVertical: 'True'
    label: Gain
    maximum: '100'
    minimum: '0'
    msize: '300'
    position: '2'
    scaleFactor: '1'
    showValue: 'False'
    type: int
    value: gain
  states: {}
- name: guiextra_levelgauge_0_0
  id: guiextra_levelgauge
  parameters:
    backgroundColor: yellow
    barColor: red
    fontColor: default
    gui_hint: 2,4,1,1
    isVertical: 'False'
    label: Gain
    maximum: '100'
    minimum: '0'
    msize: '300'
    position: '2'
    scaleFactor: '1'
    showValue: 'True'
    type: int
    value: gain
  states: {}
- name: ledstatus
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0,2,1,1
    initPressed: 'True'
    label: LED
    pressBackgroundColor: green
    pressed: 'True'
    relBackgroundColor: red
    released: 'False'
    type: bool
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: guiextra_compass_0
  id: guiextra_compass
  parameters:
    backgroundColor: default
    fullNeedle: '1'
    gui_hint: 1,1,1,2
    min_size: '150'
    name: Azimuth
    needleBodyColor: black
    needleTipColor: red
    position: '1'
    scaleColor: black
    setDebug: 'False'
    update_time: '0.10'
    usemsg: 'True'
  states: {}
- name: guiextra_graphicitem_0
  id: guiextra_graphicitem
  parameters:
    file: /opt/sdr/gnuradio/Flowgraphs/Production/noaa19.jpeg
    fixedsize: 'False'
    gui_hint: 0,4,1,1
    height: '0'
    scaleImage: 'False'
    width: '0'
  states: {}
- name: guiextra_ledindicator_0
  id: guiextra_ledindicator
  parameters:
    gui_hint: 0,3,1,1
    label: AOS
    maxSize: '40'
    offColor: red
    onColor: green
    position: '1'
    state: ledstatus
  states: {}

connections:
- [angle, value, guiextra_compass_0, angle]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
